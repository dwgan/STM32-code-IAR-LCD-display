<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM32F10X_Template.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>tft</name>
        </batchDefinition>
    </batchBuild>
</workspace>
